# Keil uVision project Final Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Final Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Project Headers
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Project C Files
    ./: UART0_TxRx.c main.c ServoInit.c motor.c
  group Project Headers
    ./Project Headers/: UART0_TxRx.h motor.h
    ./: ServoInit.h
software components: CMSIS:CORE 5.1.2, Device:Startup 2.5.0
